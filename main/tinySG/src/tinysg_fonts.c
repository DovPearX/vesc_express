#include "tinysg_internal.h"
#include <string.h>

static const uint8_t font_3x5_rows[95 * 5] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x00, 0x02, 0x05, 0x05, 0x00, 0x00, 0x00, 0x05, 0x07, 0x05, 0x07,
    0x05, 0x03, 0x06, 0x03, 0x06, 0x02, 0x05, 0x01, 0x02, 0x04, 0x05, 0x02, 0x05, 0x02, 0x05, 0x03, 0x02, 0x02, 0x00,
    0x00, 0x00, 0x01, 0x02, 0x02, 0x02, 0x01, 0x04, 0x02, 0x02, 0x02, 0x04, 0x00, 0x05, 0x02, 0x05, 0x00, 0x00, 0x02,
    0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01,
    0x01, 0x02, 0x04, 0x04, 0x07, 0x05, 0x05, 0x05, 0x07, 0x02, 0x06, 0x02, 0x02, 0x07, 0x06, 0x01, 0x07, 0x04, 0x07,
    0x06, 0x01, 0x03, 0x01, 0x06, 0x05, 0x05, 0x07, 0x01, 0x01, 0x07, 0x04, 0x06, 0x01, 0x06, 0x03, 0x04, 0x07, 0x05,
    0x07, 0x07, 0x01, 0x02, 0x02, 0x02, 0x07, 0x05, 0x07, 0x05, 0x07, 0x07, 0x05, 0x07, 0x01, 0x06, 0x00, 0x02, 0x00,
    0x02, 0x00, 0x00, 0x02, 0x00, 0x02, 0x04, 0x01, 0x02, 0x04, 0x02, 0x01, 0x00, 0x07, 0x00, 0x07, 0x00, 0x04, 0x02,
    0x01, 0x02, 0x04, 0x06, 0x01, 0x02, 0x00, 0x02, 0x07, 0x05, 0x07, 0x04, 0x03, 0x02, 0x05, 0x07, 0x05, 0x05, 0x06,
    0x05, 0x06, 0x05, 0x06, 0x03, 0x04, 0x04, 0x04, 0x03, 0x06, 0x05, 0x05, 0x05, 0x06, 0x07, 0x04, 0x06, 0x04, 0x07,
    0x07, 0x04, 0x06, 0x04, 0x04, 0x03, 0x04, 0x05, 0x05, 0x03, 0x05, 0x05, 0x07, 0x05, 0x05, 0x07, 0x02, 0x02, 0x02,
    0x07, 0x01, 0x01, 0x01, 0x05, 0x02, 0x05, 0x05, 0x06, 0x05, 0x05, 0x04, 0x04, 0x04, 0x04, 0x07, 0x05, 0x07, 0x07,
    0x05, 0x05, 0x05, 0x07, 0x07, 0x07, 0x05, 0x02, 0x05, 0x05, 0x05, 0x02, 0x06, 0x05, 0x06, 0x04, 0x04, 0x02, 0x05,
    0x05, 0x07, 0x03, 0x06, 0x05, 0x06, 0x05, 0x05, 0x03, 0x04, 0x02, 0x01, 0x06, 0x07, 0x02, 0x02, 0x02, 0x02, 0x05,
    0x05, 0x05, 0x05, 0x07, 0x05, 0x05, 0x05, 0x05, 0x02, 0x05, 0x05, 0x07, 0x07, 0x05, 0x05, 0x05, 0x02, 0x05, 0x05,
    0x05, 0x05, 0x02, 0x02, 0x02, 0x07, 0x01, 0x02, 0x04, 0x07, 0x03, 0x02, 0x02, 0x02, 0x03, 0x04, 0x04, 0x02, 0x01,
    0x01, 0x06, 0x02, 0x02, 0x02, 0x06, 0x02, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x04, 0x02, 0x00,
    0x00, 0x00, 0x02, 0x05, 0x07, 0x05, 0x05, 0x06, 0x05, 0x06, 0x05, 0x06, 0x03, 0x04, 0x04, 0x04, 0x03, 0x06, 0x05,
    0x05, 0x05, 0x06, 0x07, 0x04, 0x06, 0x04, 0x07, 0x07, 0x04, 0x06, 0x04, 0x04, 0x03, 0x04, 0x05, 0x05, 0x03, 0x05,
    0x05, 0x07, 0x05, 0x05, 0x07, 0x02, 0x02, 0x02, 0x07, 0x01, 0x01, 0x01, 0x05, 0x02, 0x05, 0x05, 0x06, 0x05, 0x05,
    0x04, 0x04, 0x04, 0x04, 0x07, 0x05, 0x07, 0x07, 0x05, 0x05, 0x05, 0x07, 0x07, 0x07, 0x05, 0x02, 0x05, 0x05, 0x05,
    0x02, 0x06, 0x05, 0x06, 0x04, 0x04, 0x02, 0x05, 0x05, 0x07, 0x03, 0x06, 0x05, 0x06, 0x05, 0x05, 0x03, 0x04, 0x02,
    0x01, 0x06, 0x07, 0x02, 0x02, 0x02, 0x02, 0x05, 0x05, 0x05, 0x05, 0x07, 0x05, 0x05, 0x05, 0x05, 0x02, 0x05, 0x05,
    0x07, 0x07, 0x05, 0x05, 0x05, 0x02, 0x05, 0x05, 0x05, 0x05, 0x02, 0x02, 0x02, 0x07, 0x01, 0x02, 0x04, 0x07, 0x03,
    0x02, 0x04, 0x02, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x02, 0x01, 0x02, 0x06, 0x00, 0x02, 0x05, 0x00, 0x00,
};
const tinysg_font tinysg_font_3x5 = {.width = 3, .height = 5, .first = 32, .count = 95, .rows = font_3x5_rows};

static const uint8_t font_5x7_rows[95 * 7] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x04, 0x00, 0x04, 0x00, 0x00, 0x0a, 0x0a, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x0a, 0x0e, 0x0a, 0x0e, 0x0a, 0x00, 0x00, 0x06, 0x0c, 0x06, 0x0c, 0x04, 0x00, 0x00, 0x0a, 0x02,
    0x04, 0x08, 0x0a, 0x00, 0x00, 0x04, 0x0a, 0x04, 0x0a, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x02, 0x04, 0x04, 0x04, 0x02, 0x00, 0x00, 0x08, 0x04, 0x04, 0x04, 0x08, 0x00, 0x00, 0x00, 0x0a, 0x04, 0x0a, 0x00,
    0x00, 0x00, 0x00, 0x04, 0x0e, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0e,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x02, 0x04, 0x08, 0x08, 0x00, 0x0e, 0x11,
    0x13, 0x15, 0x19, 0x11, 0x0e, 0x04, 0x0c, 0x04, 0x04, 0x04, 0x04, 0x0e, 0x0e, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1f,
    0x1e, 0x01, 0x01, 0x0e, 0x01, 0x01, 0x1e, 0x02, 0x06, 0x0a, 0x12, 0x1f, 0x02, 0x02, 0x1f, 0x10, 0x10, 0x1e, 0x01,
    0x01, 0x1e, 0x06, 0x08, 0x10, 0x1e, 0x11, 0x11, 0x0e, 0x1f, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08, 0x0e, 0x11, 0x11,
    0x0e, 0x11, 0x11, 0x0e, 0x0e, 0x11, 0x11, 0x0f, 0x01, 0x02, 0x0c, 0x00, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00,
    0x00, 0x04, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02, 0x04, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x0e, 0x00, 0x0e, 0x00,
    0x00, 0x00, 0x08, 0x04, 0x02, 0x04, 0x08, 0x00, 0x00, 0x0c, 0x02, 0x04, 0x00, 0x04, 0x00, 0x00, 0x0e, 0x0a, 0x0e,
    0x08, 0x06, 0x00, 0x0e, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e, 0x0f, 0x10,
    0x10, 0x10, 0x10, 0x10, 0x0f, 0x1c, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1c, 0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x1f,
    0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x10, 0x0f, 0x10, 0x10, 0x17, 0x11, 0x11, 0x0f, 0x11, 0x11, 0x11, 0x1f, 0x11,
    0x11, 0x11, 0x0e, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0e, 0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0c, 0x11, 0x12, 0x14,
    0x18, 0x14, 0x12, 0x11, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1f, 0x11, 0x1b, 0x15, 0x15, 0x11, 0x11, 0x11, 0x11,
    0x19, 0x15, 0x13, 0x11, 0x11, 0x11, 0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10,
    0x10, 0x0e, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0d, 0x1e, 0x11, 0x11, 0x1e, 0x14, 0x12, 0x11, 0x0f, 0x10, 0x10, 0x0e,
    0x01, 0x01, 0x1e, 0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e, 0x11, 0x11,
    0x11, 0x11, 0x0a, 0x0a, 0x04, 0x11, 0x11, 0x11, 0x15, 0x15, 0x1b, 0x11, 0x11, 0x0a, 0x0a, 0x04, 0x0a, 0x0a, 0x11,
    0x11, 0x11, 0x0a, 0x04, 0x04, 0x04, 0x04, 0x1f, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1f, 0x00, 0x06, 0x04, 0x04, 0x04,
    0x06, 0x00, 0x00, 0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x00, 0x0c, 0x04, 0x04, 0x04, 0x0c, 0x00, 0x00, 0x04, 0x0a,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x0e, 0x01, 0x0f, 0x11, 0x0f, 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x1e, 0x00, 0x00, 0x0f, 0x10, 0x10, 0x10,
    0x0f, 0x01, 0x01, 0x0d, 0x13, 0x11, 0x11, 0x0f, 0x00, 0x00, 0x0e, 0x11, 0x1f, 0x10, 0x0f, 0x06, 0x09, 0x08, 0x1c,
    0x08, 0x08, 0x08, 0x00, 0x0f, 0x11, 0x11, 0x0f, 0x01, 0x1e, 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11, 0x04, 0x00,
    0x0c, 0x04, 0x04, 0x04, 0x0e, 0x02, 0x00, 0x06, 0x02, 0x02, 0x12, 0x0c, 0x10, 0x10, 0x12, 0x14, 0x18, 0x14, 0x12,
    0x0c, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0e, 0x00, 0x00, 0x1a, 0x15, 0x15, 0x15, 0x15, 0x00, 0x00, 0x16, 0x19, 0x11,
    0x11, 0x11, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e, 0x00, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x00, 0x0f, 0x11,
    0x11, 0x0f, 0x01, 0x01, 0x00, 0x00, 0x16, 0x19, 0x10, 0x10, 0x10, 0x00, 0x00, 0x0f, 0x10, 0x0e, 0x01, 0x1e, 0x08,
    0x08, 0x1c, 0x08, 0x08, 0x09, 0x06, 0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0d, 0x00, 0x00, 0x11, 0x11, 0x0a, 0x0a,
    0x04, 0x00, 0x00, 0x11, 0x11, 0x15, 0x15, 0x0a, 0x00, 0x00, 0x11, 0x0a, 0x04, 0x0a, 0x11, 0x00, 0x11, 0x11, 0x0f,
    0x01, 0x02, 0x1c, 0x00, 0x00, 0x1f, 0x02, 0x04, 0x08, 0x1f, 0x00, 0x06, 0x04, 0x08, 0x04, 0x06, 0x00, 0x00, 0x04,
    0x04, 0x04, 0x04, 0x04, 0x00, 0x00, 0x0c, 0x04, 0x02, 0x04, 0x0c, 0x00, 0x00, 0x00, 0x04, 0x0a, 0x00, 0x00, 0x00,
};
const tinysg_font tinysg_font_5x7 = {.width = 5, .height = 7, .first = 32, .count = 95, .rows = font_5x7_rows};

static uint32_t font_offset(const uint8_t *data) {
  return (uint32_t)data[0] << 24 | (uint32_t)data[1] << 16 | (uint32_t)data[2] << 8 | data[3];
}

bool tinysg_font_load(tinysg_font *font, const uint8_t *data, size_t bytes) {
  if (!font || !data || bytes < 8 || memcmp(data, "TSF1", 4) || !data[5] || !data[6] || !data[7]) return false;
  unsigned count = data[5], height = data[6], width = 0;
  size_t header = 8 + (size_t)count * 8;
  if ((unsigned)data[4] + count > 256 || bytes < header) return false;
  for (unsigned i = 0; i < count; i++) {
    const uint8_t *record = data + 8 + i * 8;
    size_t offset = font_offset(record), length = ((size_t)record[4] * height + 1) / 2;
    if (!record[5] || record[6] || record[7] || offset < header || offset > bytes || length > bytes - offset)
      return false;
    if (record[4] > width) width = record[4];
  }
  *font = (tinysg_font){.width = (uint8_t)width,
                        .height = (uint8_t)height,
                        .first = data[4],
                        .count = (uint8_t)count,
                        .rows = data,
                        .format = 1,
                        .nominal = data[7],
                        .bytes = bytes};
  return true;
}

static const uint8_t *font_record(const tinysg_font *font, unsigned character) {
  if (character < font->first || character - font->first >= font->count) character = '?';
  if (character < font->first || character - font->first >= font->count) return NULL;
  return font->rows + 8 + (character - font->first) * 8;
}

static unsigned font_alpha(const tinysg_font *font, unsigned character, unsigned x, unsigned y) {
  const uint8_t *record = font_record(font, character);
  if (!record || x >= record[4] || y >= font->height) return 0;
  size_t pixel = (size_t)y * record[4] + x;
  uint8_t value = font->rows[font_offset(record) + pixel / 2];
  return (pixel & 1 ? value & 15 : value >> 4) * 17;
}

uint16_t tinysg_text_width(const tinysg_font *font, const char *text, unsigned size) {
  if (!font || !text) return 0;
  uint64_t width = 0;
  for (size_t i = 0; text[i] && i < 1024; i++) {
    const uint8_t *record = font->format ? font_record(font, (unsigned char)text[i]) : NULL;
    width += record ? record[5] : font->width + 1;
  }
  if (font->format)
    width = (width * (size ? size : font->nominal) + font->nominal / 2) / font->nominal;
  else
    width = (width ? width - 1 : 0) * (size ? size : 1);
  return width > UINT16_MAX ? UINT16_MAX : (uint16_t)width;
}

unsigned tinysg_text_alpha(const tinysg_node *node, int32_t x, int32_t y) {
  const tinysg_font *font = node->font;
  if (!font || !font->format || !node->text) return 0;
  int32_t px = x - node->x, py = y - node->y;
  if (px < 0 || py < 0) return 0;
  unsigned size = node->font_size ? node->font_size : font->nominal;
  unsigned sx = (unsigned)px * font->nominal / size, sy = (unsigned)py * font->nominal / size;
  for (const unsigned char *text = (const unsigned char *)node->text; *text; text++) {
    const uint8_t *record = font_record(font, *text);
    unsigned advance = record ? record[5] : font->width + 1;
    if (sx < advance) return font_alpha(font, *text, sx, sy);
    sx -= advance;
  }
  return 0;
}

void tinysg_paint_text(const tinysg_node *node, tinysg_area tile, uint8_t *pixels) {
  const tinysg_font *font = node->font;
  unsigned size = node->font_size ? node->font_size : font->nominal;
  tinysg_area bounds = tinysg_node_bounds(node);
  int32_t top = tile.y > bounds.y ? tile.y : bounds.y;
  int32_t bottom = tile.y + tile.height < bounds.y + bounds.height ? tile.y + tile.height : bounds.y + bounds.height;
  unsigned opacity = tinysg_opacity(node);
  for (int32_t y = top; y < bottom; y++) {
    unsigned source_y = (unsigned)(y - node->y) * font->nominal / size;
    unsigned advance = 0;
    for (const unsigned char *text = (const unsigned char *)node->text; *text; text++) {
      const uint8_t *record = font_record(font, *text);
      if (!record) {
        advance += font->width + 1;
        continue;
      }
      int32_t origin = node->x + (int32_t)((uint64_t)advance * size / font->nominal);
      int32_t end = node->x + (int32_t)(((uint64_t)(advance + record[4]) * size + font->nominal - 1) / font->nominal);
      int32_t left = origin > tile.x ? origin : tile.x, right = end < tile.x + tile.width ? end : tile.x + tile.width;
      for (int32_t x = left; x < right; x++) {
        if (x < bounds.x || x >= bounds.x + bounds.width) continue;
        unsigned source_x = (unsigned)(x - node->x) * font->nominal / size - advance;
        unsigned alpha = (font_alpha(font, *text, source_x, source_y) * opacity + 127) / 255;
        if (!alpha) continue;
        uint16_t color = node->color;
        if (!tinysg_style_pixel_bounds(node, &bounds, x, y, &color)) continue;
        size_t index = ((size_t)(y - tile.y) * tile.width + x - tile.x) * 2;
        if (alpha != 255)
          color = tinysg_blend((uint16_t)(pixels[index] << 8 | pixels[index + 1]), color, (uint8_t)alpha);
        pixels[index] = (uint8_t)(color >> 8);
        pixels[index + 1] = (uint8_t)color;
      }
      advance += record[5];
    }
  }
}

bool tinysg_font_pixel(const tinysg_font *font, unsigned character, unsigned x, unsigned y) {
  if (font && font->format) return font_alpha(font, character, x, y) != 0;
  if (!font || !font->rows || !font->width || font->width > 8 || x >= font->width || y >= font->height) return false;
  if (character < font->first || character - font->first >= font->count) character = '?';
  if (character < font->first || character - font->first >= font->count) return false;
  uint8_t row = font->rows[(character - font->first) * font->height + y];
  return (row & (1U << (font->width - 1 - x))) != 0;
}
